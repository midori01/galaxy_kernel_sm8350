## drivers/rekernel_x/Kconfig
```kconfig
config REKERNEL_X
	bool "Re:Kernel-X"
	default n
	help
	  Build Re:Kernel-X as a built-in driver.
```
